# Keil uVision project BasicOS.uvprojx, settings and files
target BasicOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G070RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00009000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BasicOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32G070xx
  c include: ..\..\..\eventos;..\..\..\test;..\mcu
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group user
    ../user/: main.c port_stm32g070.c
  group BasicOS
    ../../../eventos/: eventos.c
  group MCU
    ../mcu/: startup_stm32g070xx.s stm32g0xx_it.c system_stm32g0xx.c
  group Test
    ../../../test/: test_01.c test_02.c test_03.c
software components: CMSIS:CORE 5.5.0
