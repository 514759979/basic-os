# Keil uVision project basic_os.uvprojx, settings and files
target basic_os (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G070RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00009000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: basic_os
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G070xx
  c include: ..\..\..\BasicOS;..\..\..\mcu\stm32g070\STM32G0xx_HAL_Driver\Inc;..\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group user
    ../user/: bsp.c cb_basic_os.c main.c test_basic_os.c
  group basic_os
    ../../../BasicOS/: basic_os.c
    ../../../BasicOS/port/arm_m0/: cpu.c port_mdk.s
  group mcu
    ../user/: stm32g0xx_it.c
    ../../../mcu/stm32g070/STM32G070/: system_stm32g0xx.c
    ../../../mcu/stm32g070/STM32G070/arm/: startup_stm32g070xx.s
  group hal
    ../../../mcu/stm32g070/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_hal_usart.c stm32g0xx_hal_usart_ex.c
software components: CMSIS:CORE 5.5.0
