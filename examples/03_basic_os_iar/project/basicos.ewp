# IAR project basicos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32G070RB ST STM32G070RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G070xx
  ICCARM.CCIncludePath2: ..\..\..\..\eLab\RTOS\BasicOS; ..\..\..\..\mcu\stm32g070\CMSIS; ..\..\..\..\mcu\stm32g070\STM32G070; ..\..\..\..\mcu\stm32g070\STM32G0xx_HAL_Driver\Inc; ..\user
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: basicos.srec
  ILINK.IlinkOutputFile: basicos.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../user/: bsp.c main.c test_basic_os.c
  group BasicOS
    ../../../../eLab/RTOS/BasicOS/: basic_os.c basic_os.h port_icc.s
    ../user/: cb_basic_os.c
  group HAL
    ../../../../mcu/stm32g070/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c
  group MCU
    ../user/: startup_stm32g070xx.s stm32g0xx_it.c system_stm32g0xx.c
