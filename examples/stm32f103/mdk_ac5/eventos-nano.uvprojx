# Keil uVision project eventos-nano.uvprojx, settings and files
target EventOS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: eventos-nano
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,
  c include: ..\APP;..\MCU;..\..\..\eventos;..\..\..\3rd
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../User/: main.c port_stm32f103.c
  group MCU
    ../MCU/: stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s
  group EventOS
    ../../../eventos/: eventos.c
